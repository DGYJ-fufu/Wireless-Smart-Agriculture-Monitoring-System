# Keil uVision project Sensor_Node_Ra02.uvprojx, settings and files
target Sensor_Node_Ra02 (6230000::V6.23::ARMCLANG)
  device: STM32U031C8Tx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: Sensor_Node_Ra02 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U031xx
  c include: ../Core/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include;../Application/DeviceProperties;../Application/LoRaProtocol;../Drivers/LoRa;../Drivers/BH1750;../Drivers/BMP280;../Drivers/GP02;../Drivers/W25QXX;../Drivers/SHT40;../Drivers/Battery;../Application/ConfigManager;../Application/KeyHandler;../Application/StateManager;../Application/CliManager;../Application/PowerManager
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32u031xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c usart.c rtc.c spi.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_ll_adc.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_ll_i2c.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/BSP
    ../Drivers/LoRa/: LoRa.c
    ../Drivers/BH1750/: bh1750.c
    ../Drivers/BMP280/: bmp280.c
    ../Drivers/GP02/: gps.c
    ../Drivers/W25QXX/: w25qxx.c
    ../Drivers/SHT40/: sht40.c
    ../Drivers/Battery/: battery.c
  group Application/DeviceProperties
    ../Application/DeviceProperties/: device_properties.c
  group Application/LoRaProtocol
    ../Application/LoRaProtocol/: lora_protocol.c
  group Application/ConfigManager
    ../Application/ConfigManager/: config_manager.c
  group Application/KeyHandler
    ../Application/KeyHandler/: key_handler.c
  group Application/CliManager
    ../Application/CliManager/: cli_manager.c
software components: CMSIS:CORE 4.3.0
